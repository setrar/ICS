options:
  parameters:
    generate_options: qt_gui
    id: QT_210
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Bandwidth
  id: variable_qtgui_range
  parameters:
    start: 200e3
    step: '100'
    stop: 56e6
    value: 20e6
  states: {}
- name: Frequency
  id: variable_qtgui_range
  parameters:
    start: 70e6
    step: '1000'
    stop: 6000e6
    value: 870e6
  states: {}
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '40'
    value: '10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: 495M
    freq: '-2M'
    offset: '0'
    phase: '0'
    samp_rate: 8M
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: Bandwidth
    center_freq0: Frequency
    dev_addr: '"serial=30C51C1"'
    gain0: RF_Gain
    samp_rate: Bandwidth
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_source_0, command]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
