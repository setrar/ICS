options:
  parameters:
    generate_options: qt_gui
    id: fm_radio
    output_language: python
    title: fm-radio
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 94.1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 250e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '96000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '20'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 0,0,2,1
    name: FFT Plot
    type: complex
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: RF Spectrum
    label1: Demod Spectrum
    num_tabs: '2'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '96'
    interp: '250'
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    comment: |-
      name=lab1_xcvr,product=B200mini,serial=30C51C1,type=b200,uhd

      https://wiki.gnuradio.org/index.php/USRP_Source
    dev_addr: ''
    gain0: '15'
    samp_rate: samp_rate
    stream_args: '0'
    stream_chans: ''
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
